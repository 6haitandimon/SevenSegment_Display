#include "DisplayController.h"

//private
uint32_t DisplayController::reverseNumber(int num) {
  int reversed = 0;

  while (num != 0) {
    int digit = num % 10;
    reversed = reversed * 10 + digit;
    num /= 10;
  }

  return reversed;
}

//public
void DisplayController::initialize() {
    driver->initialize();
}
DisplayController::DisplayController(IDisplayDriver *driver) : driver(driver){}


void DisplayController::displayDigit(uint32_t digit, uint8_t position)  {
  position -= 1;
  digit = reverseNumber(digit);
  while(digit > 0){
    driver->displayDigit(digit % 10, position);
    position++;
    digit /= 10;
  }
}

void DisplayController::clearDisplay() {
    driver->clearDisplay();
}
void DisplayController::update() {
  driver->updateDisplay();
}
void DisplayController::displayChar(const char *string, uint8_t position) {
  position--;

  for(int i = 0; i < strlen(string); i++){
    if(string[i] == '.')
      position--;
    driver->displayChar(toupper(string[i]), position);
    position++;
  }
}
