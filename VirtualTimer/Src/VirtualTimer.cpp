#include "VirtualTimer.h"

VirtualTimer::VirtualTimer() : duration(0), remaining(0), active(false), callback(nullptr) {}

void VirtualTimer::start(uint32_t duration_ms, bool cyclic, void (*callback)()) {
  this->duration = duration_ms;
  this->remaining = duration_ms;
  this->callback = callback;
  this->isCyclic = cyclic;
  this->active = true;
}

void VirtualTimer::stop() {
  this->active = false;
}

void VirtualTimer::tick() {
  if (active && remaining > 0) {
    remaining--;
    if (remaining == 0) {
      if (callback) {
        callback();
        active = false;
      }
      if(isCyclic){
        this->remaining = this->duration;
        active = true;
      }
    }
  }
}


bool VirtualTimer::isActive() const {
  return this->active;
}

